# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c
  group time0_init
    ./: time0_init.c time0_init.h
  group time0_rountine
    ./: time0_rountine.c
