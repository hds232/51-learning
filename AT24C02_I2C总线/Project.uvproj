# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
  group New Group 1
    ./: I2C.c I2C.h
  group New Group 2
    ./: AT24C02.c AT24C02.h
  group New Group 3
    ./: LCD1602.c LCD1602.h
