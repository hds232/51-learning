# Keil uVision project 1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c
  group Source Group of mine
    ./: delay.c puyuxin.h
  group lcd1602
    ./: lcd1602.c lcd1602.h public.c public.h
