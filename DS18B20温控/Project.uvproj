# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group MAIN
    ./: main.c
  group AT24C02
    ./: AT24C02.c AT24C02.h IIC.c IIC.h
  group Delay
    ./: Delay.c Delay.h
  group LCD1602
    ./: LCD1602.c LCD1602.h
  group DS18B20
    ./: DS18B20.c DS18B20.h BUS.c BUS.h
  group Key
    ./: Key.c Key.h
  group Timer0
    ./: Timer0.c Timer0.h
