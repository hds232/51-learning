# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group main
    ./: STARTUP.A51 main.c
  group lcd1602
    ./: lcd1602.c lcd1602.h public.c public.h
  group delay
    ./: delay.c delay.h
  group matrixkey
    ./: matrixkey.c matrixkey.h
