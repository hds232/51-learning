# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
  group New Group 1
    ./: Mscreen.c Mscreen.h
  group New Group 2
    ./: Delay.c Delay.h
  group New Group 3
    ./: Timer0.c Timer0.h
