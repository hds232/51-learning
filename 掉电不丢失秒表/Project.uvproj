# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
  group New Group 1
    ./: Ntube.c Ntube.h
  group New Group 2
    ./: Delay.c Delay.h
  group New Group 3
    ./: Key.c Key.h
  group New Group 4
    ./: AT24C02.c AT24C02.h I2C.c I2C.h
